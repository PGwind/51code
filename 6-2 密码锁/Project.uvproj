# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ../6-1 矩阵键盘/: Delay.c LCD1602.c main.c MatrixKey.c MatrixKey.h LCD1602.h Delay.h
