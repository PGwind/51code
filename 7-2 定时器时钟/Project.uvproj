# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c Timer0.h Delay.h
    ../5-2 LCD1602调试工具/: LCD1602.c Delay.c
    ../7-1 按键控制LED流水灯模式/: Timer0.c
